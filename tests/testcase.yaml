## tests/testcase.yaml
```yaml
tests:
  firmware.devx:
    platform_allow:
      - native_sim
    tags: firmware rendering
```
